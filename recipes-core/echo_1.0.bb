SUMMARY = "UDP echo server"
DESCRIPTION = "Simple UDP echo server"
LICENSE = "GPL-3.0"
SRC_URI = "https://github.com/vitoTomas/servx-echo.git;branch=main"

inherit autotools
